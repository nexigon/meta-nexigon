require nexigon-agent.inc

SRC_URI = "git://github.com/nexigon/nexigon.git;branch=main;protocol=https"
# Tag v0.7.0.
SRCREV = "c17a888122d33a2a4fae8ace83b02bc51b2083e3"
