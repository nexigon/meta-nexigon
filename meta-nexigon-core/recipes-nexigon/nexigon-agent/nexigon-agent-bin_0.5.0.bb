AGENT_VERSION = "0.5.0"
SRC_URI[x86_64.sha256sum] = "a6c234fc80c8dfa66fc13c01c3d13f26b05b49e6b52814ce06376c8bb44c26de"
SRC_URI[aarch64.sha256sum] = "84a572b620fae13be1a689c085a3b85fff24954e0c5edb4ab56e60fac9311c19"

require nexigon-agent-bin.inc