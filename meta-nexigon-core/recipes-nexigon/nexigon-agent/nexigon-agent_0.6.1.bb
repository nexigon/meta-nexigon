require nexigon-agent.inc

# Release 0.6.1 is a hotfix on the `release/0.6` branch.
SRC_URI = "git://github.com/nexigon/nexigon.git;branch=release/0.6;protocol=https"
SRCREV = "6f567619a7be1935c59abff8d4df20bcb387209e"
