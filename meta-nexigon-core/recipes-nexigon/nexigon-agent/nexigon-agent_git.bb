PV = "0+git"
SRCREV = "${AUTOREV}"

require nexigon-agent.inc
